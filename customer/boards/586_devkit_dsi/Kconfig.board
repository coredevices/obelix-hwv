## customer/boards/em-lb586/hcpu/Kconfig.board
```kconfig
config BSP_USING_BOARD_EM_LB586XXX
    bool
    select SOC_SF32LB58X
    select BF0_HCPU
    default y

rsource "../Kconfig.board"
```
